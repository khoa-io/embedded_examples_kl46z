<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader_mocktest.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>bootloader_mocktest</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>bootloader_mocktest</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ksdk_hal_lib</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ksdk_hal_lib</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bootloader_mocktest</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>ksdk_hal_lib</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bootloader_mocktest</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ksdk_hal_lib</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


