# IAR project bootloader_mocktest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLL4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../platform/CMSIS/Include; ../platform/devices; ../platform/devices/MKL46Z4/include; ../platform/devices/MKL46Z4/startup; ../platform/hal/inc; ../platform/system/inc; ../../..; ../platform/hal/src/adc16; ../platform/hal/src/cmp; ../platform/hal/src/dac; ../platform/hal/src/dma; ../platform/hal/src/dmamux; ../platform/hal/src/gpio; ../platform/hal/src/i2c; ../platform/hal/src/llwu; ../platform/hal/src/lpsci; ../platform/hal/src/lptmr; ../platform/hal/src/mcg; ../platform/hal/src/osc; ../platform/hal/src/pit; ../platform/hal/src/port; ../platform/hal/src/rcm; ../platform/hal/src/rtc; ../platform/hal/src/sai; ../platform/hal/src/sim/MKL46Z4; ../platform/hal/src/slcd; ../platform/hal/src/smc; ../platform/hal/src/spi; ../platform/hal/src/tpm; ../platform/hal/src/tsi; ../platform/hal/src/uart; ../platform/hal/src/cop
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: bootloader_mocktest.out
  ILINK.IlinkIcfFile: ../platform/devices/MKL46Z4/linker/iar/MKL46Z256xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 5
  ICCARM.CCDefines: CPU_MKL46Z256VLL4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../lib/ksdk_hal_lib/iar/KL46Z4/debug/libksdk_hal.a
  group sources
    ../: board.c board.h Flash.c Flash.h gpio.c gpio.h loader.c loader.h main.c port.c port.h queue.c queue.h srec_reader.c srec_reader.h uart.c uart.h
  group startup
    ../platform/devices/: startup.c startup.h
    ../platform/devices/MKL46Z4/startup/iar/: startup_MKL46Z4.s
    ../platform/devices/MKL46Z4/startup/: system_MKL46Z4.c system_MKL46Z4.h
