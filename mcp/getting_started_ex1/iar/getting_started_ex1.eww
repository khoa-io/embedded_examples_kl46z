<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
	<batchBuild>
		<batchDefinition>
			<name>all</name>
			<member>
				<project>getting_started_ex1</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>getting_started_ex1</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ksdk_hal_lib</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>ksdk_hal_lib</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Release</name>
			<member>
				<project>getting_started_ex1</project>
				<configuration>Release</configuration>
			</member>
			<member>
				<project>ksdk_hal_lib</project>
				<configuration>Release</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>Debug</name>
			<member>
				<project>getting_started_ex1</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>ksdk_hal_lib</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
	<project>
		<path>$WS_DIR$/getting_started_ex1.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$/../lib/ksdk_hal_lib/iar/KL46Z4/ksdk_hal_lib.ewp</path>
	</project>
</workspace>