# IAR project ksdk_hal_lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL46Z256xxx4 Freescale MKL46Z256xxx4
  ICCARM.CCDefines: DEBUG; CPU_MKL46Z256VLH4
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../platform/CMSIS/Include; ../../../../platform/devices; ../../../../platform/devices/MKL46Z4/include; ../../../../platform/devices/MKL46Z4/startup; ../../../../platform/utilities/inc; ../../../../platform/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL46Z256VLH4
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group platform/hal/adc16
    ../../../../platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../platform/hal/inc/: fsl_adc16_hal.h
  group platform/hal/cmp
    ../../../../platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../platform/hal/inc/: fsl_cmp_hal.h
  group platform/hal/cop
    ../../../../platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../platform/hal/inc/: fsl_cop_hal.h
  group platform/hal/dac
    ../../../../platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../platform/hal/inc/: fsl_dac_hal.h
  group platform/hal/dma
    ../../../../platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../platform/hal/inc/: fsl_dma_hal.h
  group platform/hal/dmamux
    ../../../../platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../platform/hal/inc/: fsl_dmamux_hal.h
  group platform/hal/gpio
    ../../../../platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../platform/hal/inc/: fsl_gpio_hal.h
  group platform/hal/i2c
    ../../../../platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../platform/hal/inc/: fsl_i2c_hal.h
  group platform/hal/llwu
    ../../../../platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../platform/hal/inc/: fsl_llwu_hal.h
  group platform/hal/lpsci
    ../../../../platform/hal/src/lpsci/: fsl_lpsci_hal.c
    ../../../../platform/hal/inc/: fsl_lpsci_hal.h
  group platform/hal/lptmr
    ../../../../platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../platform/hal/inc/: fsl_lptmr_hal.h
  group platform/hal/mcg
    ../../../../platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform/hal/osc
    ../../../../platform/hal/src/osc/: fsl_osc_hal.c
    ../../../../platform/hal/inc/: fsl_osc_hal.h
  group platform/hal/pit
    ../../../../platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../platform/hal/inc/: fsl_pit_hal.h
  group platform/hal/port
    ../../../../platform/hal/src/port/: fsl_port_hal.c
    ../../../../platform/hal/inc/: fsl_port_hal.h
  group platform/hal/pmc
    ../../../../platform/hal/inc/: fsl_pmc_hal.h
  group platform/hal/rcm
    ../../../../platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../platform/hal/inc/: fsl_rcm_hal.h
  group platform/hal/rtc
    ../../../../platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../platform/hal/inc/: fsl_rtc_hal.h
  group platform/hal/sai
    ../../../../platform/hal/src/sai/: fsl_sai_hal.c
    ../../../../platform/hal/inc/: fsl_sai_hal.h
  group platform/hal/sim
    ../../../../platform/hal/src/sim/MKL46Z4/: fsl_sim_hal_MKL46Z4.c
    ../../../../platform/hal/inc/: fsl_sim_hal.h
  group platform/hal/smc
    ../../../../platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../platform/hal/inc/: fsl_smc_hal.h
  group platform/hal/spi
    ../../../../platform/hal/src/spi/: fsl_spi_hal.c
    ../../../../platform/hal/inc/: fsl_spi_hal.h
  group platform/hal/tpm
    ../../../../platform/hal/inc/: fsl_tpm_hal.h
    ../../../../platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform/hal/tsi
    ../../../../platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform/hal/uart
    ../../../../platform/hal/inc/: fsl_uart_hal.h
    ../../../../platform/hal/src/uart/: fsl_uart_hal.c
